# IAR project Project.ewp, settings and files
configuration STM8S003F3 (STM8)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8S_EVAL; ..\..\..\Utilities\STM8S_EVAL\STM8S-128_EVAL; ..\..\..\Utilities\STM8S_EVAL\Common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_i2c.c stm8s_itc.c stm8s_rst.c stm8s_tim5.c stm8s_tim6.c stm8s_uart2.c stm8s_uart4.c
  group User
    ../: ADXL.c BMP.c FLASH.c fonts.h I2C.c main.c OLED.c SPI.c stm8s_it.c Timers.c UART.c
